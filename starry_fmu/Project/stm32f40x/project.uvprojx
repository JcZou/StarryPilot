# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (6060000::V6.6::.\ARMCLANG)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: starry_fmu +hex
  AfterMake: fromelf --bin !L --output build/starry_fmu.bin
  c flags: Optim=4 uC99=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F427X,__VFP_FP__,ARM_MATH_MATRIX_CHECK,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED=1
  c include: ..\..\Library\STM_Lib\STM32F4xx_StdPeriph_Driver\inc;..\..\Library\STM_Lib\CMSIS\Include;..\..\Library\STM_Lib\CMSIS\Device\ST\STM32F4xx\Include;..\..\Library\mavlink\v1.0;..\..\Library\mavlink\v1.0\common;..\..\Library\Fatfs;..\..\Driver\usb\inc;..\..\Driver\include;..\..\RTOS\components\finsh;..\..\RTOS\libcpu\arm\common;..\..\RTOS\libcpu\arm\cortex-m4;..\..\RTOS\include;..\..\HAL\include;..\..\Framework\include;..\stm32f40x
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1fc000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    ../../Application/: application.c startup.c
  group Framework
    ../../Framework/source/INS/: att_estimator.c AHRS.c pos_estimator.c declination.c
    ../../Framework/source/Control/: att_pid.c adrc.c adrc_att.c control_main.c control_alt.c
    ../../Framework/source/Filter/: butter.c filter.c fir.c
    ../../Framework/source/Console/: console.c msh_usr_cmd.c mavlink_console.c
    ../../Framework/source/Copter/: copter_main.c fast_loop.c
    ../../Framework/source/Sensor/: calibration.c sensor_manager.c
    ../../Framework/source/Time/: delay.c
    ../../Framework/source/FileManager/: file_manager.c
    ../../Framework/source/Global/: global.c
    ../../Framework/source/HIL/: hil_interface.c
    ../../Framework/source/KF/: kf.c ekf.c
    ../../Framework/source/LED/: led.c
    ../../Framework/source/Logger/: logger.c
    ../../Framework/source/Mavproxy/: mavproxy.c mavproxy_rtt.c mavlink_status.c mavlink_param.c
    ../../Framework/source/Param/: param.c
    ../../Framework/source/PID/: pid.c
    ../../Framework/source/RC/: rc.c
    ../../Framework/source/Statistic/: statistic.c
    ../../Framework/source/System/: system.c
    ../../Framework/source/STARRYIO/: starryio_manager.c starryio_protocol.c starryio_uploader.c
    ../../Framework/source/Test/: test.c
    ../../Framework/source/uMCN/: uMCN.c
    ../../Framework/source/YXML/: yxml.c
    ../../Framework/source/StateEstimator/: state_est.c
  group Math
    ../../Framework/source/Math/: ap_math.c light_matrix.c quaternion.c conversion.c
  group HAL
    ../../HAL/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../HAL/motor/: motor.c
    ../../HAL/pin/: pin.c
    ../../HAL/rc_receiver/: rc_receiver.c
    ../../HAL/serial/: serial.c
    ../../HAL/spi/: spi_core.c spi_dev.c
    ../../HAL/tools/: completion.c dataqueue.c portal.c workqueue.c
    ../../HAL/usb/: cdcacm.c
  group Driver
    ../../Driver/board/: board.c
    ../../Driver/: stm32f4xx_it.c
    ../../Driver/gpio/: gpio.c
    ../../Driver/gps/: gps.c
    ../../Driver/hw_timer/: drv_hwtimer.c
    ../../Driver/i2c/: i2c_soft.c
    ../../Driver/l3gd20h/: l3gd20h.c
    ../../Driver/lsm303d/: lsm303d.c
    ../../Driver/ms5611/: ms5611.c
    ../../Driver/pwm/: pwm.c pwm_io.c
    ../../Driver/rtc/: stm32f4_rtc.c
    ../../Driver/spi/: stm32f4_spi.c
    ../../Driver/usart/: usart.c
    ../../Driver/hmc5883/: hmc5883.c
    ../../Driver/sdio/: sdio.c
    ../../Driver/lidar/: lidar.c
    ../../Driver/mpu6000/: mpu6000.c
  group Utils
    ../../Framework/source/Tool/: ringbuffer.c fifo.c
  group usb
    ../../Driver/usb/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core_loopback.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group finsh
    ../../RTOS/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group Kernel
    ../../RTOS/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Fatfs
    ../../Library/Fatfs/: diskio.c ff.c fs.c
    ../../Library/Fatfs/option/: syscall.c unicode.c
  group STM32_StdPeriph
    ../../Library/STM_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../Library/STM_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CORTEX-M4
    ../../RTOS/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../RTOS/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../Library/STM_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427x.s
  group DSP-Lib
    ../../Library/STM_Lib/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../../Library/STM_Lib/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_abs_f32.c arm_add_f32.c arm_dot_prod_f32.c arm_mult_f32.c arm_negate_f32.c arm_offset_f32.c arm_scale_f32.c arm_sub_f32.c
    ../../Library/STM_Lib/CMSIS/DSP_Lib/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../../Library/STM_Lib/CMSIS/DSP_Lib/Source/SupportFunctions/: arm_copy_f32.c arm_fill_f32.c
software components: CMSIS:CORE 5.0.1
